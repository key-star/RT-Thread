# Keil uVision project RT-Thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: ..\cubemx\Core\Inc;..\cubemx\Drivers\CMSIS\Include;..\cubemx\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\cubemx\Drivers\STM32F1xx_HAL_Driver\Inc;..\cubemx\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;..\board;..\ports\fal;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include\drivers;..\..\..\..\components\drivers\include\ipc;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\kernel\include;..\..\..\..\kernel\include\libc;..\..\..\..\components\libc\compilers\armlibc;..\..\..\..\components\libc\compilers\common;..\..\..\..\components\fal\inc;..\..\..\..\components\finsh;..\..\..\..\components\dfs\include;..\..\..\..\components\dfs\filesystems\devfs;..\..\..\..\components\dfs\filesystems\elmfat;..\..\..\..\components\net\lwip-2.0.2\src;..\..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\..\components\net\netdev\include;..\..\..\..\components\net\sal_socket\include;..\..\..\..\components\net\sal_socket\include\socket;..\..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\..\components\cJSON;..\..\..\..\components\mbedtls\mbedtls\include;..\..\..\..\components\mbedtls\ports\inc;..\..\..\..\components\webclient\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp/cubemx
    ../cubemx/MDK-ARM/: startup_stm32f103xe.s
    ../cubemx/Core/Src/: stm32f1xx_hal_msp.c system_stm32f1xx.c
  group cpu
    ../../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group bsp/STM32_HAL
    ../cubemx/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group bsp/board
    ../board/: board.c main.c
  group bsp/drivers
    ../../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c drv_spi.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f1.c
  group bsp/ports
    ../ports/enc28j60/: enc28j60_init.c
    ../ports/fal/: fal_flash_sfud_port.c
    ../ports/spi_flash/: mount_table.c spi_flash_init.c
  group components/drivers
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c enc28j60.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group kernel
    ../../../../kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group components/lib
    ../../../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c stdio.c
    ../../../../components/libc/compilers/common/: time.c
  group components/fal
    ../../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group components/finsh
    ../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group components/dfs
    ../../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group components/dfs/devfs
    ../../../../components/dfs/filesystems/devfs/: devfs.c
  group components/dfs/elmfat
    ../../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group components/lwip/api
    ../../../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group components/lwip/core
    ../../../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group components/lwip/core/ipv4
    ../../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group components/lwip/netif
    ../../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
  group components/lwip/arch
    ../../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group components/netdev
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group components/sal
    ../../../../components/net/sal_socket/src/: sal_socket.c
    ../../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group components/netutils
    ../../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group components/cJSON
    ../../../../components/cJSON/: cJSON.c cJSON_port.c cJSON_util.c
  group components/mbedtls/library
    ../../../../components/mbedtls/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group components/mbedtls/ports
    ../../../../components/mbedtls/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group components/webclient
    ../../../../components/webclient/src/: webclient.c webclient_file.c
  group applications
    ../../../../applications/fal-samples/: fal_sample.c
    ../../../../applications/mbedtls-samples/: tls_app_test.c
    ../../../../applications/network-sample/: httpclient_sample.c tcpclient_sample.c tcpclient_select_sample.c tcpserver_sample.c udpclient_sample.c udpserver_sample.c
    ../../../../applications/webclient-samples/: webclient_get_sample.c webclient_post_sample.c
  group documentation
    ../documentation/: readme.txt
