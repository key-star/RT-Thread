# Keil uVision project RT-Thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC,STM32F429xx
  c include: ..\cubemx\Core\Inc;..\cubemx\Drivers\CMSIS\Include;..\cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;..\board;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include\drivers;..\..\..\..\components\drivers\include\ipc;..\..\..\..\kernel\include;..\..\..\..\kernel\include\libc;..\..\..\..\components\libc\compilers\armlibc;..\..\..\..\components\libc\compilers\common;..\..\..\..\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp/cubemx
    ../cubemx/MDK-ARM/: startup_stm32f429xx.s
    ../cubemx/Core/Src/: stm32f4xx_hal_msp.c system_stm32f4xx.c
  group cpu
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group bsp/STM32_HAL
    ../cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group bsp/board
    ../board/: board.c main.c
  group bsp/drivers
    ../../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group components/drivers
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/misc/: pin.c
  group kernel
    ../../../../kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group components/lib
    ../../../../components/libc/compilers/common/: time.c
  group components/finsh
    ../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group documentation
    ../documentation/: readme.txt
