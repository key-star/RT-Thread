# Keil uVision project RT-Thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC,STM32F429xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\cubemx\Core\Inc;..\cubemx\Drivers\CMSIS\Include;..\cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;..\board;..\ports\sdram;..\ports\fal;..\ports\lcd;..\ports\lvgl;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\components\drivers\touch;..\..\..\..\components\drivers\touch\gt917s\inc;..\..\..\..\components\pcf8574;..\..\..\..\kernel\include;..\..\..\..\components\libc\compilers\common;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\posix\io\stdio;..\..\..\..\components\fal\inc;..\..\..\..\components\finsh;..\..\..\..\components\dfs\include;..\..\..\..\components\dfs\filesystems\devfs;..\..\..\..\components\dfs\filesystems\elmfat;..\..\..\..\components\net\lwip\port;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\..\components\net\netdev\include;..\..\..\..\components\net\sal\impl;..\..\..\..\components\net\sal\include;..\..\..\..\components\net\sal\include\dfs_net;..\..\..\..\components\net\sal\include\socket;..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\components\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp/cubemx
    ../cubemx/MDK-ARM/: startup_stm32f429xx.s
    ../cubemx/Core/Src/: stm32f4xx_hal_msp.c system_stm32f4xx.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group bsp/STM32_HAL
    ../cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c
  group bsp/board
    ../board/: board.c main.c
  group bsp/drivers
    ../../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c drv_sdram.c drv_soft_i2c.c drv_spi.c drv_sdio.c drv_rtc.c drv_eth.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    ../ports/lcd/: drv_lcd.c
  group bsp/ports
    ../ports/fal/: fal_flash_sfud_port.c
    ../ports/spi_flash/: mount_table.c spi_flash_init.c
    ../ports/touch/: touch_init.c
    ../ports/eth/: phy_reset.c
    ../ports/lvgl/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lv_rt_thread_port.c
  group components/drivers
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../../components/drivers/rtc/: rtc.c
    ../../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../../components/drivers/touch/: touch.c
    ../../../../components/drivers/touch/gt917s/src/: gt917s.c
    ../../../../components/pcf8574/: pcf8574.c
  group kernel
    ../../../../kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group components/libc
    ../../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../../components/libc/posix/io/stdio/: libc.c
  group components/fal
    ../../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group components/finsh
    ../../../../components/finsh/: cmd.c msh.c msh_file.c shell.c
  group components/dfs
    ../../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group components/dfs/devfs
    ../../../../components/dfs/filesystems/devfs/: devfs.c
  group components/dfs/elmfat
    ../../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group components/lwip/port
    ../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group components/lwip/netif
    ../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
  group components/lwip/core
    ../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group components/lwip/core/ipv4
    ../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group components/lwip/api
    ../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group components/lwip/apps
    ../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
  group components/netdev
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group components/sal
    ../../../../components/net/sal/src/: sal_socket.c
    ../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../components/net/sal/impl/: af_inet_lwip.c proto_mbedtls.c
    ../../../../components/net/sal/dfs_net/: dfs_net.c
  group components/lvgl/core
    ../../../../components/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group components/lvgl/draw
    ../../../../components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group components/lvgl/draw/sw
    ../../../../components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group components/lvgl/extra
    ../../../../components/lvgl/src/extra/: lv_extra.c
    ../../../../components/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../../components/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../../components/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../../components/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../../components/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../components/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../components/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../../components/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../components/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../components/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../components/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../../components/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../components/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../components/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../components/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../../components/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../../components/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../../components/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../../components/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../components/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../../components/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../components/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../components/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../components/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../components/lvgl/src/extra/widgets/win/: lv_win.c
  group components/lvgl/font
    ../../../../components/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group components/lvgl/hal
    ../../../../components/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group components/lvgl/misc
    ../../../../components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group components/lvgl/widgets
    ../../../../components/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group applications
    ../../../../applications/touch-samples/: gt917s_sample.c
  group documentation
    ../documentation/: readme.txt
