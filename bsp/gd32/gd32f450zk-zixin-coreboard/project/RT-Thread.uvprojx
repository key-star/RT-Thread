# Keil uVision project RT-Thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, RT_USING_ARM_LIBC, GD32F4XX
  c include: ..\..\libraries\GD32F4xx_Libraries\CMSIS;..\..\libraries\GD32F4xx_Libraries\CMSIS\GD\GD32F4xx\Include;..\..\libraries\GD32F4xx_Libraries\GD32F4xx_standard_peripheral\Include;..\..\libraries\GD32F4xx_Libraries\drivers;..\board;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include\drivers;..\..\..\..\components\drivers\include\ipc;..\..\..\..\kernel\include;..\..\..\..\components\libc\compilers\common;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp/CMSIS
    ../../libraries/GD32F4xx_Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group bsp/GD32_Libraries
    ../../libraries/GD32F4xx_Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_crc.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_usart.c
  group bsp/board
    ../board/: board.c main.c system_gd32f4xx.c
  group bsp/drivers
    ../../libraries/GD32F4xx_Libraries/drivers/: drv_usart.c
  group components/drivers
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/serial/: serial.c
  group kernel
    ../../../../kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group components/finsh
    ../../../../components/finsh/: cmd.c msh.c msh_file.c shell.c
  group documentation
    ../documentation/: readme.txt
