# Keil uVision project RT-Thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC,STM32F407xx
  c include: ..\cubemx\Core\Inc;..\cubemx\Drivers\CMSIS\Include;..\cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;..\board;..\ports\sram;..\ports\fal;..\ports\lcd;..\ports\lvgl;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include\drivers;..\..\..\..\components\drivers\include\ipc;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\components\drivers\touch;..\..\..\..\components\drivers\touch\gt917s\inc;..\..\..\..\kernel\include;..\..\..\..\kernel\include\libc;..\..\..\..\components\libc\compilers\common;..\..\..\..\components\libc\compilers\armlibc;..\..\..\..\components\libc\termios;..\..\..\..\components\libc\getline;..\..\..\..\components\agile_console\inc;..\..\..\..\components\fal\inc;..\..\..\..\components\finsh;..\..\..\..\components\rt-i2c-tools\src;..\..\..\..\components\vt100\src;..\..\..\..\components\vt100\examples;..\..\..\..\components\TJpgDec;..\..\..\..\components\dfs\include;..\..\..\..\components\dfs\filesystems\devfs;..\..\..\..\components\dfs\filesystems\elmfat;..\..\..\..\components\mem_sandbox;..\..\..\..\components\optparse;..\..\..\..\components\vi;..\..\..\..\components\net\lwip-2.0.2\src;..\..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\..\components\net\at\include;..\..\..\..\components\net\at\at_socket;..\..\..\..\components\at_device\inc;..\..\..\..\components\at_device\class\esp8266;..\..\..\..\components\net\netdev\include;..\..\..\..\components\mbedtls\ports\inc;..\..\..\..\components\mbedtls\mbedtls\include;..\..\..\..\components\net\sal_socket\include;..\..\..\..\components\net\sal_socket\include\socket;..\..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\..\components\net\sal_socket\impl;..\..\..\..\components\netutils\ntp;..\..\..\..\components\netutils\tftp;..\..\..\..\components\agile_telnet\inc;..\..\..\..\components\agile_ftp\inc;..\..\..\..\components\webclient\inc;..\..\..\..\components\cJSON;..\..\..\..\components\STemWin\inc\5.44;..\..\..\..\components\STemWin\demo;..\..\..\..\components\STemWin\examples;..\..\..\..\components\STemWin\examples\5.44;..\..\..\..\components\lv_lib_bmp;..\..\..\..\components\lv_lib_png;..\..\..\..\components\lv_lib_split_jpg;..\..\..\..\components\LittlevGL2RTT;..\..\..\..\components\LittlevGL2RTT\lvgl;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_core;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_draw;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_font;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_gpu;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_hal;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_misc;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_themes;..\..\..\..\components\LittlevGL2RTT\lvgl\lv_widgets;..\..\..\..\applications\rtt_tetris;..\..\..\..\applications\lv-samples;..\..\..\..\applications\lv-samples\lv_olympic\custom;..\..\..\..\applications\lv-samples\lv_olympic\generated;..\..\..\..\applications\lv-samples\lv_olympic\generated\guider_customer_fonts;..\..\..\..\applications\lv-samples\lv_olympic\generated\guider_fonts;..\..\..\..\applications\webclient-samples
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp/cubemx
    ../cubemx/MDK-ARM/: startup_stm32f407xx.s
    ../cubemx/Core/Src/: stm32f4xx_hal_msp.c system_stm32f4xx.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group bsp/STM32_HAL
    ../cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group bsp/board
    ../board/: board.c main.c
  group bsp/drivers
    ../../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c drv_soft_i2c.c drv_sdio.c drv_rtc.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    ../ports/lcd/: drv_lcd.c
    ../ports/sram/: drv_sram.c
  group bsp/ports
    ../ports/enc28j60/: enc28j60_init.c
    ../ports/fal/: fal_flash_sfud_port.c
    ../ports/spi_flash/: mount_table.c spi_flash_init.c
    ../ports/touch/: touch_init.c
    ../ports/ftp/: agile_ftp_init.c
  group components/drivers
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c enc28j60.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../../components/drivers/touch/: touch.c
    ../../../../components/drivers/touch/gt917s/src/: gt917s.c
    ../../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../../components/drivers/rtc/: rtc.c
  group kernel
    ../../../../kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group components/lib
    ../../../../components/libc/compilers/common/: time.c unistd.c
    ../../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../../components/libc/termios/: posix_termios.c
    ../../../../components/libc/getline/: posix_getline.c
  group components/agile_console
    ../../../../components/agile_console/src/: agile_console.c
    ../../../../components/agile_console/examples/: agile_console_serial_be.c
  group components/fal
    ../../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group components/finsh
    ../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group components/i2c_tools
    ../../../../components/rt-i2c-tools/src/: i2c_tools.cpp i2c_utils.cpp SoftwareI2C.cpp
  group components/vt100
    ../../../../components/vt100/src/: vt100.c
  group components/dfs
    ../../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group components/dfs/devfs
    ../../../../components/dfs/filesystems/devfs/: devfs.c
  group components/dfs/elmfat
    ../../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group components/mem_sandbox
    ../../../../components/mem_sandbox/: mem_sandbox.c
  group components/optparse
    ../../../../components/optparse/: optparse.c
  group components/vi
    ../../../../components/vi/: vi.c vi_utils.c
  group components/ki
    ../../../../components/ki/: ki.c
  group components/lwip/arch
    ../../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group components/lwip/netif
    ../../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
  group components/lwip/core
    ../../../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group components/lwip/core/ipv4
    ../../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group components/lwip/api
    ../../../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group components/lwip/apps
    ../../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group components/at_device
    ../../../../components/at_device/src/: at_device.c
    ../../../../components/at_device/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    ../../../../components/at_device/samples/: at_sample_esp8266.c
  group components/at
    ../../../../components/net/at/src/: at_cli.c at_client.c at_utils.c
    ../../../../components/net/at/at_socket/: at_socket.c
  group components/netdev
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group components/mbedtls/library
    ../../../../components/mbedtls/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group components/mbedtls/ports
    ../../../../components/mbedtls/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group components/sal
    ../../../../components/net/sal_socket/src/: sal_socket.c
    ../../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../../components/net/sal_socket/impl/: af_inet_at.c af_inet_lwip.c proto_mbedtls.c
    ../../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group components/netutils/ntp
    ../../../../components/netutils/ntp/: ntp.c
  group components/netutils/telnet
    ../../../../components/netutils/telnet/: telnet.c
  group components/netutils/tftp
    ../../../../components/netutils/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group components/netutils/iperf
    ../../../../components/netutils/iperf/: iperf.c
  group components/netutils/netio
    ../../../../components/netutils/netio/: netio.c
  group components/netutils/tcpdump
    ../../../../components/netutils/tcpdump/: tcpdump.c
  group components/agile_telnet
    ../../../../components/agile_telnet/src/: agile_telnet.c
  group components/agile_ftp
    ../../../../components/agile_ftp/src/: ftp.c ftp_session.c ftp_session_cmd.c
  group components/webclient
    ../../../../components/webclient/src/: webclient.c webclient_file.c
  group components/cJSON
    ../../../../components/cJSON/: cJSON.c cJSON_port.c cJSON_Utils.c
  group components/lv_lib_bmp
    ../../../../components/lv_lib_bmp/: lv_bmp.c
  group components/lv_lib_png
    ../../../../components/lv_lib_png/: lodepng.c lv_png.c
  group components/lv_lib_split_jpg
    ../../../../components/lv_lib_split_jpg/: tjpgd.c lv_sjpg.c
  group components/lvgl/lv_core
    ../../../../components/LittlevGL2RTT/lvgl/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group components/lvgl/lv_draw
    ../../../../components/LittlevGL2RTT/lvgl/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group components/lvgl/lv_font
    ../../../../components/LittlevGL2RTT/lvgl/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
  group components/lvgl/lv_hal
    ../../../../components/LittlevGL2RTT/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group components/lvgl/lv_misc
    ../../../../components/LittlevGL2RTT/lvgl/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group components/lvgl/lv_themes
    ../../../../components/LittlevGL2RTT/lvgl/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group components/lvgl/lv_widgets
    ../../../../components/LittlevGL2RTT/lvgl/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group components/lvgl/ports
    ../ports/lvgl/: littlevgl2rtt.c lv_port_fs.c
  group applications
    ../../../../applications/c2048/: 2048.c
    ../../../../components/vt100/examples/: vt_monitor.c vt_sl.c
    ../../../../applications/touch-samples/: gt917s_sample.c
    ../../../../applications/lv-samples/: littlevgl2rtt_demo.c lv_test_theme.c lv_img_test.c
    ../../../../applications/mbedtls-samples/: tls_app_test.c
    ../../../../applications/webclient-samples/: olympic_sample.c epidemic_sample.c
  group documentation
    ../documentation/: readme.txt
